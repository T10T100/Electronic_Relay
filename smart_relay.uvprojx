# Keil uVision project smart_relay.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: smart_relay +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, __hd066__
  c misc: --cpp11
  c include: .\device\inc;.\init\inc;.\user\inc;.\it;.\interface\inc;.\misc\inc;..\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group user
    ./user/src/: main.cpp
  group device
    ./device/src/: device.cpp gpio_ex.cpp relay.cpp Clock.cpp Pin.cpp
  group it
    ./it/: stm32f0xx_it.c
  group init
    ./init/src/: init.cpp
  group drivers
    ../stm32f0_stdperiph_lib/STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_syscfg.c stm32f0xx_exti.c
  group interface
    ./interface/src/: lcd.cpp
  group misc
    ./misc/src/: dtostr.cpp
software components: CMSIS:CORE 4.1.0, Device:Startup 1.5.0
